FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Enable-the-DBUS-for-wpa-supplicant.patch"
SRC_URI += "file://wpa_supplicant-easymesh.patch"
