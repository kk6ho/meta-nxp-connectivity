FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://easymesh-ping-fix.patch"

